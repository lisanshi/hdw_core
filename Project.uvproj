# Keil uVision project Project.uvproj, settings and files
target YH08 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: YH08 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .\DSP_Lib\inc;.\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: stm32f10x_it.c main.c function.c i2c_ee.c spi_flash.c lcd.c sysdate.c
  group RVMDK
    ./: stm32f10x_vector.s
  group Lib
    ./: STM32F10xR.LIB HPIR.lib motion.lib
  group DSP_Lib
    ./DSP_Lib/src/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
